Commit message: Fixed issue with pos/ori errors, plotting pos error vs ori error for every model

File: urdf/ur5.urdf (robot description, URDF)
Before this commit: robot universal_robot, 9 links, 8 joints
Links:
- link ee_link: mass None -> 0.1
